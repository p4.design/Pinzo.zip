Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-09-03T14:48:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 03 14:48:11 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{CD6638DD-5E79-428D-8425-00C8B49BF938}\ifc * Database version: 5507 * Database creation date: Tue Sep 03 14:48:11 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 03 14:48:11 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 03 14:48:11 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Pinzo, Furniture_Chairs&Stools&Benches_Bla-Station_Pinzo:Pinzo:383032
In: Level 1
Type - Material: Pine creamy natural
Type - Dimensions(Type) - NominalDepth: 634.982 mm; NominalHeight: 701.38 mm; NominalLength: 509.069 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Chairs&Stools&Benches_Bla-Station_Pinzo; ConvergoRefNr: 0099-1909-0002-SE; ManufacturerName: Bla Station; ManufacturerURL: http://www.blastation.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_26; Version: 1; VersionDate: 30/08/2019
Type - Identity Data(Type) - Collection: Pinzo; Cost: 0; Description: Pinzo is a raw-hewn, sturdy little punk of a chair. Stubby and with a springy inclination, and offers an almost brutal simplicity of construction, with a finger jointed backrest and a hole as a little handle in the lower part of the seat.; Designer: David Ericsson 2019; Manufacturer: Bla Station; Model: Pinzo; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: http://www.blastation.com/storage/ma/6b33783002f94a959df3092f5008b4c8/98969bade41247c29c05c207e3993587/pdf/BF7C89730A40121FB704FC298DEE50FEEA841812/Pinzo.pdf; Type Name: Pinzo; URL: http://www.blastation.com/products/product-families/pinzo/pinzo
Type - Materials and Finishes(Type) - ArmchairMainMaterial: Pine creamy natural
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Bla Station; Category: Armchair; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Chairs&Stools&Benches_Bla-Station_Pinzo; Features: Solid pine grove. Osmo/hard-waxed surface treatment in natural or colored. Plastic foot.; Finish: n/a; Grade: n/a; Material: Pine & plastic; ModelNumber: n/a; ModelReference: n/a; Name: Bla-Station_Pinzo; ReplacementCost: n/a; Shape: Sculptured; Size: 500x700x720 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Bla Station
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.12566 m2; Volume: 0.226721 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Chairs&Stools&Benches_Bla-Station_Pinzo: Pinzo; Family and Type: Furniture_Chairs&Stools&Benches_Bla-Station_Pinzo: Pinzo; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Chairs&Stools&Benches_Bla-Station_Pinzo: Pinzo; Type Id: Furniture_Chairs&Stools&Benches_Bla-Station_Pinzo: Pinzo; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
